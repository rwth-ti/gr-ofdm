<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>ofdm_fbmc_transmitter_demo</key>
<param><key>id</key><value>ofdm_fbmc_transmitter_demo_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
<param><key>syms_per_frame</key><value>syms_per_frame</value></param>
<param><key>carriers</key><value>carriers</value></param>
<param><key>theta_sel</key><value>theta_sel</value></param>
<param><key>exclude_preamble</key><value>exclude_preamble</value></param>
<param><key>sel_preamble</key><value>1</value></param>
<param><key>zero_pads</key><value>zero_pads</value></param>
<param><key>extra_pad</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>syms_per_frame</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>K</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>carriers</value></param>
<param><key>value</key><value>M</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>qam_size</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>theta_sel</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>exclude_preamble</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>625e3/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>zero_pads</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>ofdm_fbmc_symbol_creation_bvc</key>
<param><key>id</key><value>ofdm_fbmc_symbol_creation_bvc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>0.00001</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>SNR</value></param>
<param><key>value</key><value>10</value></param>
<param><key>start</key><value>-20</value></param>
<param><key>stop</key><value>80</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>carriers</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>carriers</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0</value></param>
<param><key>type</key><value>'BER'</value></param>
<param><key>win_size</key><value>1000</value></param>
<param><key>bits_per_symbol</key><value>(int)(math.log(qam_size)/math.log(2))</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>nconnections</key><value>2</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>qam_size</value></param>
<param><key>num_samps</key><value>10000000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>ofdm_fbmc_channel_hier_cc</key>
<param><key>id</key><value>ofdm_fbmc_channel_hier_cc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>syms_per_frame</key><value>syms_per_frame</value></param>
<param><key>exclude_multipath</key><value>0</value></param>
<param><key>sel_taps</key><value>2</value></param>
<param><key>freq_offset</key><value>0</value></param>
<param><key>exclude_noise</key><value>0</value></param>
<param><key>sel_noise_type</key><value>201</value></param>
<param><key>SNR</key><value>SNR</value></param>
<param><key>exclude_preamble</key><value>exclude_preamble</value></param>
<param><key>sel_preamble</key><value>1</value></param>
<param><key>zero_pads</key><value>zero_pads</value></param>
<param><key>extra_pad</key><value>0</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>ofdm_fbmc_receiver_demo</key>
<param><key>id</key><value>ofdm_fbmc_receiver_demo_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
<param><key>syms_per_frame</key><value>syms_per_frame</value></param>
<param><key>theta_sel</key><value>theta_sel</value></param>
<param><key>carriers</key><value>carriers</value></param>
<param><key>exclude_preamble</key><value>exclude_preamble</value></param>
<param><key>sel_preamble</key><value>1</value></param>
<param><key>zero_pads</key><value>zero_pads</value></param>
<param><key>extra_pad</key><value>0</value></param>
<param><key>sel_eq</key><value>0</value></param>
</block>
<block>
<key>ofdm_fbmc_symbol_estimation_vcb</key>
<param><key>id</key><value>ofdm_fbmc_symbol_estimation_vcb_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>name</key><value>BER (IAM-C with repetition 1-tap)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>avg</key><value>1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>min</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_vector_to_stream_0_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_symbol_creation_bvc_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_receiver_demo_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_symbol_estimation_vcb_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>ofdm_fbmc_symbol_creation_bvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_symbol_creation_bvc_0</source_block_id><sink_block_id>ofdm_fbmc_transmitter_demo_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_channel_hier_cc_0</source_block_id><sink_block_id>ofdm_fbmc_receiver_demo_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_transmitter_demo_0</source_block_id><sink_block_id>ofdm_fbmc_channel_hier_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_receiver_demo_0</source_block_id><sink_block_id>ofdm_fbmc_symbol_estimation_vcb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
