<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SNR</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>qam_size</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pr_norm</value></param>
<param><key>value</key><value>math.sqrt(5)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SNR</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>theta_sel</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>K</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>right_preamble</value></param>
<param><key>value</key><value>[-1j/pr_norm, 1/pr_norm, 1j/pr_norm, -1/pr_norm]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>zero_pads</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>left_preamble</value></param>
<param><key>value</key><value>[1j/pr_norm, -1/pr_norm, -1j/pr_norm, 1/pr_norm]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_preamble_0</value></param>
<param><key>value</key><value>[1, -1j, -1, 1j]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_preamble</value></param>
<param><key>value</key><value>[1/pr_norm, -1j/pr_norm, -1/pr_norm, 1j/pr_norm]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>[0]*M*zero_pads+0*left_preamble*((int)(M/len(left_preamble)))+3*center_preamble*((int)(M/len(center_preamble)))+right_preamble*((int)(M/len(right_preamble)))*0+[0]*M*zero_pads</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3.125e6*2/10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>exclude_preamble</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>carriers</value></param>
<param><key>value</key><value>M</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>syms_per_frame</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_0</value></param>
<param><key>value</key><value>[0]*M*zero_pads+0*left_preamble*((int)(M/len(left_preamble)))+center_preamble_0*((int)(M/len(center_preamble)))+right_preamble*((int)(M/len(right_preamble)))*0+[0]*M*zero_pads</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>qam_size</value></param>
<param><key>num_samps</key><value>10000000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>ofdm_fbmc_polyphase_network_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_polyphase_network_vcvc_3</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>reverse</key><value>True</value></param>
<param><key>lp</key><value>K*M-1</value></param>
</block>
<block>
<key>ofdm_fbmc_polyphase_network_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_polyphase_network_vcvc_2</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>reverse</key><value>True</value></param>
<param><key>lp</key><value>K*M-1</value></param>
</block>
<block>
<key>ofdm_fbmc_junction_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_junction_vcvc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>num_input</key><value>2</value></param>
</block>
<block>
<key>ofdm_fbmc_symbol_estimation_vcb</key>
<param><key>id</key><value>ofdm_fbmc_symbol_estimation_vcb_0</value></param>
<param><key>M</key><value>carriers</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>M</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>[]</value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>ofdm_fbmc_separate_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_separate_vcvc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>num_output</key><value>2</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0</value></param>
<param><key>type</key><value>'BER'</value></param>
<param><key>win_size</key><value>1000</value></param>
<param><key>bits_per_symbol</key><value>(int)(math.log(qam_size)/math.log(2))</value></param>
</block>
<block>
<key>ofdm_fbmc_beta_multiplier_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_beta_multiplier_vcvc_1</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>lp</key><value>K*M-1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>2*K-1-1</value></param>
<param><key>vlen</key><value>M</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>min</key><value>0</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>carriers</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>carriers</value></param>
</block>
<block>
<key>ofdm_fbmc_beta_multiplier_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_beta_multiplier_vcvc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>lp</key><value>K*M-1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>M</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>window</key><value>[]</value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>ofdm_fbmc_oqam_preprocessing_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_oqam_preprocessing_vcvc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>theta_sel</key><value>0</value></param>
</block>
<block>
<key>ofdm_vector_padding</key>
<param><key>id</key><value>ofdm_vector_padding_0</value></param>
<param><key>carriers</key><value>carriers</value></param>
<param><key>vlen</key><value>M</value></param>
<param><key>padding_left</key><value> -1</value></param>
</block>
<block>
<key>ofdm_fbmc_separate_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_separate_vcvc_1</value></param>
<param><key>M</key><value>M</value></param>
<param><key>num_output</key><value>2</value></param>
</block>
<block>
<key>ofdm_fbmc_polyphase_network_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_polyphase_network_vcvc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>reverse</key><value>False</value></param>
<param><key>lp</key><value>K*M-1</value></param>
</block>
<block>
<key>ofdm_fbmc_polyphase_network_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_polyphase_network_vcvc_1</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>reverse</key><value>False</value></param>
<param><key>lp</key><value>K*M-1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>[1.0/(M*0.6863)]*M</value></param>
<param><key>vlen</key><value>M</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>2.43e9</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>multi</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>input_index</key><value>exclude_preamble</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>vlen</key><value>M</value></param>
</block>
<block>
<key>ofdm_vector_mask</key>
<param><key>id</key><value>ofdm_vector_mask_0</value></param>
<param><key>vlen</key><value>M</value></param>
<param><key>cut_left</key><value>(M-carriers)/2</value></param>
<param><key>mask_len</key><value>carriers</value></param>
<param><key>mask</key><value>[]</value></param>
</block>
<block>
<key>ofdm_fbmc_symbol_creation_bvc</key>
<param><key>id</key><value>ofdm_fbmc_symbol_creation_bvc_0</value></param>
<param><key>M</key><value>carriers</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>removeout.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>carriers</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>input.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>carriers</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>scpout.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>carriers</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>maskout.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>carriers</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>oqamin.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>carriers</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>input_index</key><value>exclude_preamble</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>vlen</key><value>M</value></param>
</block>
<block>
<key>ofdm_fbmc_oqam_postprocessing_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_oqam_postprocessing_vcvc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>theta_sel</key><value>0</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>nconnections</key><value>2</value></param>
</block>
<block>
<key>ofdm_fbmc_channel_hier_cc</key>
<param><key>id</key><value>ofdm_fbmc_channel_hier_cc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>syms_per_frame</key><value>syms_per_frame</value></param>
<param><key>exclude_multipath</key><value>0</value></param>
<param><key>sel_taps</key><value>2</value></param>
<param><key>freq_offset</key><value>0</value></param>
<param><key>exclude_noise</key><value>1</value></param>
<param><key>sel_noise_type</key><value>201</value></param>
<param><key>SNR</key><value>SNR</value></param>
<param><key>exclude_preamble</key><value>exclude_preamble</value></param>
<param><key>zero_pads</key><value>1</value></param>
</block>
<block>
<key>ofdm_fbmc_overlapping_serial_to_parallel_cvc</key>
<param><key>id</key><value>ofdm_fbmc_overlapping_serial_to_parallel_cvc_0</value></param>
<param><key>M</key><value>M</value></param>
</block>
<block>
<key>ofdm_fbmc_overlapping_parallel_to_serial_vcc</key>
<param><key>id</key><value>ofdm_fbmc_overlapping_parallel_to_serial_vcc_0</value></param>
<param><key>M</key><value>M</value></param>
</block>
<block>
<key>ofdm_fbmc_insert_preamble_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_insert_preamble_vcvc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>syms_per_frame</key><value>syms_per_frame</value></param>
<param><key>preamble</key><value>preamble_0</value></param>
</block>
<block>
<key>ofdm_fbmc_remove_preamble_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_remove_preamble_vcvc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>syms_per_frame</key><value>syms_per_frame</value></param>
<param><key>preamble_length</key><value>len(preamble_0)</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1</value></param>
<param><key>vlen</key><value>M</value></param>
</block>
<block>
<key>ofdm_fbmc_channel_hier_cc</key>
<param><key>id</key><value>ofdm_fbmc_channel_hier_cc_0_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>syms_per_frame</key><value>syms_per_frame</value></param>
<param><key>exclude_multipath</key><value>0</value></param>
<param><key>sel_taps</key><value>2</value></param>
<param><key>freq_offset</key><value>0</value></param>
<param><key>exclude_noise</key><value>1</value></param>
<param><key>sel_noise_type</key><value>201</value></param>
<param><key>SNR</key><value>SNR</value></param>
<param><key>exclude_preamble</key><value>exclude_preamble</value></param>
<param><key>zero_pads</key><value>1</value></param>
</block>
<block>
<key>ofdm_fbmc_subchannel_processing_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_subchannel_processing_vcvc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>syms_per_frame</key><value>syms_per_frame</value></param>
<param><key>preamble</key><value>preamble_0</value></param>
<param><key>sel_eq</key><value>2</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>file</key><value>estimate.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>M</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>ofdm_fbmc_symbol_creation_bvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_overlapping_parallel_to_serial_vcc_0</source_block_id><sink_block_id>ofdm_fbmc_channel_hier_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_channel_hier_cc_0</source_block_id><sink_block_id>ofdm_fbmc_overlapping_serial_to_parallel_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_separate_vcvc_0</source_block_id><sink_block_id>ofdm_fbmc_polyphase_network_vcvc_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_separate_vcvc_0</source_block_id><sink_block_id>ofdm_fbmc_polyphase_network_vcvc_3</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_overlapping_serial_to_parallel_cvc_0</source_block_id><sink_block_id>ofdm_fbmc_separate_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_overlapping_parallel_to_serial_vcc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_polyphase_network_vcvc_2</source_block_id><sink_block_id>ofdm_fbmc_junction_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_polyphase_network_vcvc_3</source_block_id><sink_block_id>ofdm_fbmc_junction_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_junction_vcvc_0</source_block_id><sink_block_id>fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>ofdm_fbmc_subchannel_processing_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_vector_mask_0</source_block_id><sink_block_id>ofdm_fbmc_symbol_estimation_vcb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_oqam_postprocessing_vcvc_0</source_block_id><sink_block_id>ofdm_vector_mask_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1</source_block_id><sink_block_id>ofdm_fbmc_beta_multiplier_vcvc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_vector_mask_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_beta_multiplier_vcvc_1</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_symbol_creation_bvc_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_vector_padding_0</source_block_id><sink_block_id>ofdm_fbmc_oqam_preprocessing_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_symbol_creation_bvc_0</source_block_id><sink_block_id>ofdm_vector_padding_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_polyphase_network_vcvc_0</source_block_id><sink_block_id>ofdm_fbmc_overlapping_parallel_to_serial_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_polyphase_network_vcvc_1</source_block_id><sink_block_id>ofdm_fbmc_overlapping_parallel_to_serial_vcc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_separate_vcvc_1</source_block_id><sink_block_id>ofdm_fbmc_polyphase_network_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_separate_vcvc_1</source_block_id><sink_block_id>ofdm_fbmc_polyphase_network_vcvc_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>ofdm_fbmc_beta_multiplier_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_oqam_preprocessing_vcvc_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_oqam_preprocessing_vcvc_0</source_block_id><sink_block_id>ofdm_fbmc_insert_preamble_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_beta_multiplier_vcvc_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_insert_preamble_vcvc_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>ofdm_fbmc_separate_vcvc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_vector_mask_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_symbol_creation_bvc_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_subchannel_processing_vcvc_0</source_block_id><sink_block_id>blocks_file_sink_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_remove_preamble_vcvc_0</source_block_id><sink_block_id>blocks_file_sink_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_subchannel_processing_vcvc_0</source_block_id><sink_block_id>blocks_skiphead_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0</source_block_id><sink_block_id>ofdm_fbmc_remove_preamble_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_remove_preamble_vcvc_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0</source_block_id><sink_block_id>ofdm_fbmc_oqam_postprocessing_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_channel_hier_cc_0_0</source_block_id><sink_block_id>ofdm_fbmc_overlapping_serial_to_parallel_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_overlapping_parallel_to_serial_vcc_0</source_block_id><sink_block_id>ofdm_fbmc_channel_hier_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_symbol_estimation_vcb_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_subchannel_processing_vcvc_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
