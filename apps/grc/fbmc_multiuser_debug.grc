<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>boundaries_0</value></param>
<param><key>value</key><value>[10,35,60,85,130,155]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>zero_pad</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3.125e6*2/100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>K</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_users</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>syms_per_frame</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>theta_sel</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>carriers</value></param>
<param><key>value</key><value>[boundaries[1]-boundaries[0]+1,boundaries[3]-boundaries[2]+1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>carriers_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>[boundaries[1]-boundaries[0]+1,boundaries[3]-boundaries[2]+1,boundaries[5]-boundaries[4]+1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>qam_size</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>boundaries</value></param>
<param><key>value</key><value>[10,21,22,33]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>exclude_preamble</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0_0_0_2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>qam_size</value></param>
<param><key>num_samps</key><value>10000000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>ofdm_fbmc_overlapping_serial_to_parallel_cvc</key>
<param><key>id</key><value>ofdm_fbmc_overlapping_serial_to_parallel_cvc_0</value></param>
<param><key>M</key><value>M</value></param>
</block>
<block>
<key>ofdm_fbmc_separate_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_separate_vcvc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>num_output</key><value>2</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>ofdm_fbmc_asymmetrical_vector_mask_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>start</key><value>boundaries[0]</value></param>
<param><key>end</key><value>boundaries[1]</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_0_2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>carriers[0]</value></param>
</block>
<block>
<key>ofdm_fbmc_symbol_creation_bvc</key>
<param><key>id</key><value>ofdm_fbmc_symbol_creation_bvc_0</value></param>
<param><key>M</key><value>carriers[0]</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>u1-u2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>nconnections</key><value>2</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>u1-ref</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>nconnections</key><value>2</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>carriers[0]</value></param>
</block>
<block>
<key>ofdm_fbmc_symbol_estimation_vcb</key>
<param><key>id</key><value>ofdm_fbmc_symbol_estimation_vcb_0</value></param>
<param><key>M</key><value>carriers[0]</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0_0</value></param>
<param><key>type</key><value>'BER'</value></param>
<param><key>win_size</key><value>1000</value></param>
<param><key>bits_per_symbol</key><value>(int)(math.log(qam_size)/math.log(2))</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>M</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0_0_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>qam_size</value></param>
<param><key>num_samps</key><value>10000000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>ofdm_fbmc_asymmetrical_vector_mask_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>start</key><value>boundaries[2]</value></param>
<param><key>end</key><value>boundaries[3]</value></param>
</block>
<block>
<key>ofdm_fbmc_oqam_postprocessing_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_oqam_postprocessing_vcvc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>theta_sel</key><value>0</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0_0_0</value></param>
<param><key>type</key><value>'BER'</value></param>
<param><key>win_size</key><value>1000</value></param>
<param><key>bits_per_symbol</key><value>(int)(math.log(qam_size)/math.log(2))</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>name</key><value>U1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0</value></param>
<param><key>name</key><value>U2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0_0_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>qam_size</value></param>
<param><key>num_samps</key><value>10000000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>'BER'</value></param>
<param><key>win_size</key><value>1000</value></param>
<param><key>bits_per_symbol</key><value>(int)(math.log(qam_size)/math.log(2))</value></param>
</block>
<block>
<key>ofdm_fbmc_symbol_estimation_vcb</key>
<param><key>id</key><value>ofdm_fbmc_symbol_estimation_vcb_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>M</key><value>carriers[0]</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
</block>
<block>
<key>ofdm_fbmc_asymmetrical_vector_mask_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>M</key><value>M</value></param>
<param><key>start</key><value>boundaries[4]</value></param>
<param><key>end</key><value>boundaries[5]</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>name</key><value>U3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>carriers[1]</value></param>
</block>
<block>
<key>ofdm_fbmc_symbol_estimation_vcb</key>
<param><key>id</key><value>ofdm_fbmc_symbol_estimation_vcb_0_0</value></param>
<param><key>M</key><value>carriers[1]</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
</block>
<block>
<key>ofdm_fbmc_remove_preamble_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_remove_preamble_vcvc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>syms_per_frame</key><value>syms_per_frame</value></param>
<param><key>sel_preamble</key><value>0</value></param>
<param><key>zero_pads</key><value>zero_pad</value></param>
<param><key>extra_pad</key><value>1</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>0</value></param>
<param><key>vlen</key><value>M</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>input_index</key><value>exclude_preamble</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>vlen</key><value>M</value></param>
</block>
<block>
<key>ofdm_fbmc_beta_multiplier_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_beta_multiplier_vcvc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>lp</key><value>K*M-1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>2*K-1-1</value></param>
<param><key>vlen</key><value>M</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>M</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value></value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>ofdm_fbmc_junction_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_junction_vcvc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>num_input</key><value>2</value></param>
</block>
<block>
<key>ofdm_fbmc_polyphase_network_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_polyphase_network_vcvc_0_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>reverse</key><value>True</value></param>
<param><key>lp</key><value>K*M-1</value></param>
</block>
<block>
<key>ofdm_fbmc_polyphase_network_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_polyphase_network_vcvc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>reverse</key><value>True</value></param>
<param><key>lp</key><value>K*M-1</value></param>
</block>
<block>
<key>ofdm_fbmc_subchannel_processing_mu_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_subchannel_processing_mu_vcvc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>syms_per_frame</key><value>syms_per_frame</value></param>
<param><key>indices</key><value>boundaries</value></param>
<param><key>sel_preamble</key><value>0</value></param>
<param><key>zero_pads</key><value>zero_pad</value></param>
<param><key>extra_pad</key><value>1</value></param>
<param><key>sel_eq</key><value>3</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>u2-ref</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>nconnections</key><value>2</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>ofdm_fbmc_transmitter_multiuser_bc</key>
<param><key>id</key><value>ofdm_fbmc_transmitter_multiuser_bc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
<param><key>syms_per_frame</key><value>syms_per_frame</value></param>
<param><key>start</key><value>boundaries[0]</value></param>
<param><key>end</key><value>boundaries[1]</value></param>
<param><key>theta_sel</key><value>theta_sel</value></param>
<param><key>exclude_preamble</key><value>exclude_preamble</value></param>
<param><key>sel_preamble</key><value>0</value></param>
<param><key>zero_pads</key><value>zero_pad</value></param>
<param><key>extra_pad</key><value>1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>noise_voltage</key><value>0.0</value></param>
<param><key>freq_offset</key><value>-5.5/M</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>taps</key><value>1.0</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>ofdm_fbmc_transmitter_multiuser_bc</key>
<param><key>id</key><value>ofdm_fbmc_transmitter_multiuser_bc_0_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
<param><key>syms_per_frame</key><value>syms_per_frame</value></param>
<param><key>start</key><value>boundaries[0]</value></param>
<param><key>end</key><value>boundaries[1]</value></param>
<param><key>theta_sel</key><value>theta_sel</value></param>
<param><key>exclude_preamble</key><value>exclude_preamble</value></param>
<param><key>sel_preamble</key><value>0</value></param>
<param><key>zero_pads</key><value>zero_pad</value></param>
<param><key>extra_pad</key><value>1</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0_0_0_2</source_block_id><sink_block_id>blocks_throttle_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0_0_0_1</source_block_id><sink_block_id>blocks_throttle_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_0_2</source_block_id><sink_block_id>ofdm_fbmc_transmitter_multiuser_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>ofdm_fbmc_overlapping_serial_to_parallel_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_overlapping_serial_to_parallel_cvc_0</source_block_id><sink_block_id>ofdm_fbmc_separate_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_separate_vcvc_0</source_block_id><sink_block_id>ofdm_fbmc_polyphase_network_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_separate_vcvc_0</source_block_id><sink_block_id>ofdm_fbmc_polyphase_network_vcvc_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_oqam_postprocessing_vcvc_0</source_block_id><sink_block_id>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_oqam_postprocessing_vcvc_0</source_block_id><sink_block_id>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0</source_block_id><sink_block_id>ofdm_fbmc_symbol_estimation_vcb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0_0</source_block_id><sink_block_id>ofdm_fbmc_symbol_estimation_vcb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_0_2</source_block_id><sink_block_id>blks2_error_rate_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_symbol_estimation_vcb_0</source_block_id><sink_block_id>blks2_error_rate_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0_0_0</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_symbol_creation_bvc_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1</source_block_id><sink_block_id>qtgui_const_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_0_1</source_block_id><sink_block_id>ofdm_fbmc_symbol_creation_bvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_symbol_estimation_vcb_0_0</source_block_id><sink_block_id>blks2_error_rate_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0_0_0_1_0</source_block_id><sink_block_id>blocks_throttle_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0_0_0</source_block_id><sink_block_id>ofdm_fbmc_symbol_estimation_vcb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_oqam_postprocessing_vcvc_0</source_block_id><sink_block_id>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0_0_0_0</source_block_id><sink_block_id>qtgui_number_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_symbol_estimation_vcb_0_0_0</source_block_id><sink_block_id>blks2_error_rate_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_0_1_0</source_block_id><sink_block_id>blks2_error_rate_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_subchannel_processing_mu_vcvc_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0</source_block_id><sink_block_id>ofdm_fbmc_oqam_postprocessing_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_remove_preamble_vcvc_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_1</source_block_id><sink_block_id>ofdm_fbmc_remove_preamble_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_1</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_subchannel_processing_mu_vcvc_0</source_block_id><sink_block_id>blocks_skiphead_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>ofdm_fbmc_subchannel_processing_mu_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_beta_multiplier_vcvc_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>ofdm_fbmc_beta_multiplier_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_junction_vcvc_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_polyphase_network_vcvc_0_0</source_block_id><sink_block_id>ofdm_fbmc_junction_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_polyphase_network_vcvc_0</source_block_id><sink_block_id>ofdm_fbmc_junction_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_transmitter_multiuser_bc_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_0_1</source_block_id><sink_block_id>blks2_error_rate_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_0_1</source_block_id><sink_block_id>ofdm_fbmc_transmitter_multiuser_bc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_transmitter_multiuser_bc_0_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
