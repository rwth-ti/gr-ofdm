<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>exclude_preamble</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>carriers</value></param>
<param><key>value</key><value>[boundaries[1]-boundaries[0]+1,boundaries[3]-boundaries[2]+1,boundaries[5]-boundaries[4]+1,boundaries[7]-boundaries[6]+1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>zero_pad</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>theta_sel</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>syms_per_frame</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>qam_size</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>K</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3.125e6*2/100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>boundaries</value></param>
<param><key>value</key><value>[10,35,60,85,130,155,200,235]</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0_0_1</value></param>
<param><key>type</key><value>'BER'</value></param>
<param><key>win_size</key><value>1000</value></param>
<param><key>bits_per_symbol</key><value>(int)(math.log(qam_size)/math.log(2))</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0_0_0</value></param>
<param><key>type</key><value>'BER'</value></param>
<param><key>win_size</key><value>1000</value></param>
<param><key>bits_per_symbol</key><value>(int)(math.log(qam_size)/math.log(2))</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>qam_size</value></param>
<param><key>num_samps</key><value>10000000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>qam_size</value></param>
<param><key>num_samps</key><value>10000000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0_0_0_2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>qam_size</value></param>
<param><key>num_samps</key><value>10000000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0_0_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>qam_size</value></param>
<param><key>num_samps</key><value>10000000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_0_2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>name</key><value>BER (User 1)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>min</key><value>0</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>name</key><value>BER (User 2)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>min</key><value>0</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>name</key><value>BER (User 4)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>min</key><value>0</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>name</key><value>BER (User 1)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>min</key><value>0</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>0.000001</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>0.000001</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>User1</value></param>
<param><key>units</key><value>%</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>100.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0</value></param>
<param><key>type</key><value>'BER'</value></param>
<param><key>win_size</key><value>1000</value></param>
<param><key>bits_per_symbol</key><value>(int)(math.log(qam_size)/math.log(2))</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0_0</value></param>
<param><key>type</key><value>'BER'</value></param>
<param><key>win_size</key><value>1000</value></param>
<param><key>bits_per_symbol</key><value>(int)(math.log(qam_size)/math.log(2))</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>0.000001</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>User3</value></param>
<param><key>units</key><value>%</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>100.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>User4</value></param>
<param><key>units</key><value>%</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>100.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>0.000001</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>User2</value></param>
<param><key>units</key><value>%</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>100.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
</block>
<block>
<key>ofdm_fbmc_asymmetrical_vector_mask_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>M</key><value>M</value></param>
<param><key>start</key><value>boundaries[2]</value></param>
<param><key>end</key><value>boundaries[3]</value></param>
</block>
<block>
<key>ofdm_fbmc_asymmetrical_vector_mask_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>M</key><value>M</value></param>
<param><key>start</key><value>boundaries[0]</value></param>
<param><key>end</key><value>boundaries[1]</value></param>
</block>
<block>
<key>ofdm_fbmc_asymmetrical_vector_mask_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>M</key><value>M</value></param>
<param><key>start</key><value>boundaries[4]</value></param>
<param><key>end</key><value>boundaries[5]</value></param>
</block>
<block>
<key>ofdm_fbmc_asymmetrical_vector_mask_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>M</key><value>M</value></param>
<param><key>start</key><value>boundaries[6]</value></param>
<param><key>end</key><value>boundaries[7]</value></param>
</block>
<block>
<key>ofdm_fbmc_transmitter_multiuser_bc</key>
<param><key>id</key><value>ofdm_fbmc_transmitter_multiuser_bc_1</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
<param><key>syms_per_frame</key><value>syms_per_frame</value></param>
<param><key>start</key><value>boundaries[2]</value></param>
<param><key>end</key><value>boundaries[3]</value></param>
<param><key>theta_sel</key><value>theta_sel</value></param>
<param><key>exclude_preamble</key><value>exclude_preamble</value></param>
<param><key>sel_preamble</key><value>0</value></param>
<param><key>zero_pads</key><value>1</value></param>
<param><key>extra_pad</key><value>0</value></param>
</block>
<block>
<key>ofdm_fbmc_transmitter_multiuser_bc</key>
<param><key>id</key><value>ofdm_fbmc_transmitter_multiuser_bc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
<param><key>syms_per_frame</key><value>syms_per_frame</value></param>
<param><key>start</key><value>boundaries[0]</value></param>
<param><key>end</key><value>boundaries[1]</value></param>
<param><key>theta_sel</key><value>theta_sel</value></param>
<param><key>exclude_preamble</key><value>exclude_preamble</value></param>
<param><key>sel_preamble</key><value>0</value></param>
<param><key>zero_pads</key><value>1</value></param>
<param><key>extra_pad</key><value>0</value></param>
</block>
<block>
<key>ofdm_fbmc_symbol_estimation_vcb</key>
<param><key>id</key><value>ofdm_fbmc_symbol_estimation_vcb_0_1</value></param>
<param><key>M</key><value>carriers[2]</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
</block>
<block>
<key>ofdm_fbmc_symbol_estimation_vcb</key>
<param><key>id</key><value>ofdm_fbmc_symbol_estimation_vcb_0_2</value></param>
<param><key>M</key><value>carriers[3]</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
</block>
<block>
<key>ofdm_fbmc_receiver_demo</key>
<param><key>id</key><value>ofdm_fbmc_receiver_demo_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
<param><key>syms_per_frame</key><value>syms_per_frame</value></param>
<param><key>theta_sel</key><value>theta_sel</value></param>
<param><key>carriers</key><value>M</value></param>
<param><key>exclude_preamble</key><value>exclude_preamble</value></param>
<param><key>sel_preamble</key><value>0</value></param>
<param><key>zero_pads</key><value>1</value></param>
<param><key>extra_pad</key><value>0</value></param>
<param><key>sel_eq</key><value>0</value></param>
</block>
<block>
<key>ofdm_fbmc_symbol_estimation_vcb</key>
<param><key>id</key><value>ofdm_fbmc_symbol_estimation_vcb_0</value></param>
<param><key>M</key><value>carriers[0]</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
</block>
<block>
<key>ofdm_fbmc_symbol_estimation_vcb</key>
<param><key>id</key><value>ofdm_fbmc_symbol_estimation_vcb_0_0</value></param>
<param><key>M</key><value>carriers[1]</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
</block>
<block>
<key>ofdm_fbmc_transmitter_multiuser_bc</key>
<param><key>id</key><value>ofdm_fbmc_transmitter_multiuser_bc_3</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
<param><key>syms_per_frame</key><value>syms_per_frame</value></param>
<param><key>start</key><value>boundaries[6]</value></param>
<param><key>end</key><value>boundaries[7]</value></param>
<param><key>theta_sel</key><value>theta_sel</value></param>
<param><key>exclude_preamble</key><value>exclude_preamble</value></param>
<param><key>sel_preamble</key><value>0</value></param>
<param><key>zero_pads</key><value>1</value></param>
<param><key>extra_pad</key><value>0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>4</value></param>
</block>
<block>
<key>ofdm_fbmc_receiver_multiuser_cb</key>
<param><key>id</key><value>ofdm_fbmc_receiver_multiuser_cb_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
<param><key>syms_per_frame</key><value>syms_per_frame</value></param>
<param><key>boundaries</key><value>boundaries</value></param>
<param><key>c1</key><value>carriers[0]</value></param>
<param><key>c2</key><value>carriers[1]</value></param>
<param><key>c3</key><value>carriers[2]</value></param>
<param><key>c4</key><value>carriers[3]</value></param>
<param><key>theta_sel</key><value>theta_sel</value></param>
<param><key>exclude_preamble</key><value>exclude_preamble</value></param>
<param><key>sel_preamble</key><value>0</value></param>
<param><key>zero_pads</key><value>1</value></param>
<param><key>extra_pad</key><value>0</value></param>
<param><key>sel_eq</key><value>0</value></param>
</block>
<block>
<key>ofdm_fbmc_transmitter_multiuser_bc</key>
<param><key>id</key><value>ofdm_fbmc_transmitter_multiuser_bc_2</value></param>
<param><key>M</key><value>M</value></param>
<param><key>K</key><value>K</value></param>
<param><key>qam_size</key><value>qam_size</value></param>
<param><key>syms_per_frame</key><value>syms_per_frame</value></param>
<param><key>start</key><value>boundaries[4]</value></param>
<param><key>end</key><value>boundaries[5]</value></param>
<param><key>theta_sel</key><value>theta_sel</value></param>
<param><key>exclude_preamble</key><value>exclude_preamble</value></param>
<param><key>sel_preamble</key><value>0</value></param>
<param><key>zero_pads</key><value>1</value></param>
<param><key>extra_pad</key><value>0</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0_0_0</source_block_id><sink_block_id>blocks_throttle_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0_0_0_0</source_block_id><sink_block_id>blocks_throttle_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0_0_0_2</source_block_id><sink_block_id>blocks_throttle_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0_0_0_1</source_block_id><sink_block_id>blocks_throttle_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_0_0</source_block_id><sink_block_id>ofdm_fbmc_transmitter_multiuser_bc_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_0</source_block_id><sink_block_id>ofdm_fbmc_transmitter_multiuser_bc_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_0_1</source_block_id><sink_block_id>ofdm_fbmc_transmitter_multiuser_bc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_0_2</source_block_id><sink_block_id>ofdm_fbmc_transmitter_multiuser_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_transmitter_multiuser_bc_3</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_transmitter_multiuser_bc_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_transmitter_multiuser_bc_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_transmitter_multiuser_bc_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>ofdm_fbmc_receiver_demo_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_receiver_demo_0</source_block_id><sink_block_id>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_receiver_demo_0</source_block_id><sink_block_id>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_receiver_demo_0</source_block_id><sink_block_id>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_receiver_demo_0</source_block_id><sink_block_id>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0</source_block_id><sink_block_id>ofdm_fbmc_symbol_estimation_vcb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0_0</source_block_id><sink_block_id>ofdm_fbmc_symbol_estimation_vcb_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0_1</source_block_id><sink_block_id>ofdm_fbmc_symbol_estimation_vcb_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_asymmetrical_vector_mask_vcvc_0_2</source_block_id><sink_block_id>ofdm_fbmc_symbol_estimation_vcb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_symbol_estimation_vcb_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_0_2</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_symbol_estimation_vcb_0_0</source_block_id><sink_block_id>blks2_error_rate_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_0_1</source_block_id><sink_block_id>blks2_error_rate_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0_0</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_symbol_estimation_vcb_0_1</source_block_id><sink_block_id>blks2_error_rate_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_symbol_estimation_vcb_0_2</source_block_id><sink_block_id>blks2_error_rate_0_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_0_0</source_block_id><sink_block_id>blks2_error_rate_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_0</source_block_id><sink_block_id>blks2_error_rate_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0_0_1</source_block_id><sink_block_id>single_pole_iir_filter_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0_0_0</source_block_id><sink_block_id>qtgui_number_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0_0_0_0</source_block_id><sink_block_id>qtgui_number_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0_0_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0_0_0</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0_0_0_0</source_block_id><sink_block_id>wxgui_numbersink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>wxgui_numbersink2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0_0</source_block_id><sink_block_id>wxgui_numbersink2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_receiver_demo_0</source_block_id><sink_block_id>ofdm_fbmc_receiver_multiuser_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_receiver_multiuser_cb_0</source_block_id><sink_block_id>ofdm_fbmc_symbol_estimation_vcb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_receiver_multiuser_cb_0</source_block_id><sink_block_id>ofdm_fbmc_symbol_estimation_vcb_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_receiver_multiuser_cb_0</source_block_id><sink_block_id>ofdm_fbmc_symbol_estimation_vcb_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_receiver_multiuser_cb_0</source_block_id><sink_block_id>ofdm_fbmc_symbol_estimation_vcb_0_2</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>ofdm_fbmc_receiver_multiuser_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
