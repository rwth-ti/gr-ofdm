<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>indices</value></param>
<param><key>value</key><value>[0,60,150,220]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>12</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulation</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_ratio</value></param>
<param><key>value</key><value>0.25</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>modulation</value></param>
<param><key>num_samps</key><value>10000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>modulation</value></param>
<param><key>num_samps</key><value>10000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0_2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>modulation</value></param>
<param><key>num_samps</key><value>10000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>modulation</value></param>
<param><key>num_samps</key><value>10000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>User0</value></param>
<param><key>units</key><value>%</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>100</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>User1</value></param>
<param><key>units</key><value>%</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>100</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>User2</value></param>
<param><key>units</key><value>%</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>100</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>User3</value></param>
<param><key>units</key><value>%</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>100</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
</block>
<block>
<key>ofdm_scfdma_receiver_cb</key>
<param><key>id</key><value>ofdm_scfdma_receiver_cb_0</value></param>
<param><key>N</key><value>N</value></param>
<param><key>M</key><value>M</value></param>
<param><key>num_users</key><value>len(indices)</value></param>
<param><key>indices</key><value>indices</value></param>
<param><key>mapping</key><value>0</value></param>
<param><key>modulation</key><value>modulation</value></param>
<param><key>cp_ratio</key><value>cp_ratio</value></param>
</block>
<block>
<key>ofdm_scfdma_transmitter_bc</key>
<param><key>id</key><value>ofdm_scfdma_transmitter_bc_0_1</value></param>
<param><key>N</key><value>N</value></param>
<param><key>M</key><value>M</value></param>
<param><key>start_index</key><value>indices[0]</value></param>
<param><key>mapping</key><value>0</value></param>
<param><key>modulation</key><value>modulation</value></param>
<param><key>cp_ratio</key><value>cp_ratio</value></param>
</block>
<block>
<key>ofdm_scfdma_transmitter_bc</key>
<param><key>id</key><value>ofdm_scfdma_transmitter_bc_0_2</value></param>
<param><key>N</key><value>N</value></param>
<param><key>M</key><value>M</value></param>
<param><key>start_index</key><value>indices[1]</value></param>
<param><key>mapping</key><value>0</value></param>
<param><key>modulation</key><value>modulation</value></param>
<param><key>cp_ratio</key><value>cp_ratio</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0</value></param>
<param><key>type</key><value>'BER'</value></param>
<param><key>win_size</key><value>1000</value></param>
<param><key>bits_per_symbol</key><value>int(math.log(modulation)/math.log(2))</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0_0</value></param>
<param><key>type</key><value>'BER'</value></param>
<param><key>win_size</key><value>1000</value></param>
<param><key>bits_per_symbol</key><value>int(math.log(modulation)/math.log(2))</value></param>
</block>
<block>
<key>ofdm_scfdma_transmitter_bc</key>
<param><key>id</key><value>ofdm_scfdma_transmitter_bc_0</value></param>
<param><key>N</key><value>N</value></param>
<param><key>M</key><value>M</value></param>
<param><key>start_index</key><value>indices[2]</value></param>
<param><key>mapping</key><value>0</value></param>
<param><key>modulation</key><value>modulation</value></param>
<param><key>cp_ratio</key><value>cp_ratio</value></param>
</block>
<block>
<key>ofdm_scfdma_transmitter_bc</key>
<param><key>id</key><value>ofdm_scfdma_transmitter_bc_0_0</value></param>
<param><key>N</key><value>N</value></param>
<param><key>M</key><value>M</value></param>
<param><key>start_index</key><value>indices[3]</value></param>
<param><key>mapping</key><value>0</value></param>
<param><key>modulation</key><value>modulation</value></param>
<param><key>cp_ratio</key><value>cp_ratio</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0_1</value></param>
<param><key>type</key><value>'BER'</value></param>
<param><key>win_size</key><value>1000</value></param>
<param><key>bits_per_symbol</key><value>int(math.log(modulation)/math.log(2))</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0_0_0</value></param>
<param><key>type</key><value>'BER'</value></param>
<param><key>win_size</key><value>1000</value></param>
<param><key>bits_per_symbol</key><value>int(math.log(modulation)/math.log(2))</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>4</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<connection><source_block_id>blks2_error_rate_0</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>ofdm_scfdma_transmitter_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>ofdm_scfdma_transmitter_bc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0_0</source_block_id><sink_block_id>wxgui_numbersink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0_0_0</source_block_id><sink_block_id>wxgui_numbersink2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0_1</source_block_id><sink_block_id>wxgui_numbersink2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_2</source_block_id><sink_block_id>ofdm_scfdma_transmitter_bc_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0_2</source_block_id><sink_block_id>blocks_throttle_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1</source_block_id><sink_block_id>ofdm_scfdma_transmitter_bc_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0_1</source_block_id><sink_block_id>blocks_throttle_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_scfdma_transmitter_bc_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>ofdm_scfdma_transmitter_bc_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ofdm_scfdma_transmitter_bc_0_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_scfdma_transmitter_bc_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>ofdm_scfdma_receiver_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_scfdma_receiver_cb_0</source_block_id><sink_block_id>blks2_error_rate_0_1</sink_block_id><source_key>3</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_scfdma_receiver_cb_0</source_block_id><sink_block_id>blks2_error_rate_0_0_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_scfdma_receiver_cb_0</source_block_id><sink_block_id>blks2_error_rate_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_scfdma_receiver_cb_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_2</source_block_id><sink_block_id>blks2_error_rate_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>blks2_error_rate_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blks2_error_rate_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
