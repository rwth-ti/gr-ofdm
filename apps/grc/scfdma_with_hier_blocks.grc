<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_ratio</value></param>
<param><key>value</key><value>0.25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulation</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>12</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>start_index</value></param>
<param><key>value</key><value>12</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>modulation</value></param>
<param><key>num_samps</key><value>10000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>ofdm_scfdma_transmitter_bc</key>
<param><key>id</key><value>ofdm_scfdma_transmitter_bc_0</value></param>
<param><key>N</key><value>N</value></param>
<param><key>M</key><value>M</value></param>
<param><key>start_index</key><value>start_index</value></param>
<param><key>mapping</key><value>0</value></param>
<param><key>modulation</key><value>modulation</value></param>
<param><key>cp_ratio</key><value>cp_ratio</value></param>
</block>
<block>
<key>ofdm_scfdma_receiver_cb</key>
<param><key>id</key><value>ofdm_scfdma_receiver_cb_0</value></param>
<param><key>N</key><value>N</value></param>
<param><key>M</key><value>M</value></param>
<param><key>start_index</key><value>start_index</value></param>
<param><key>mapping</key><value>0</value></param>
<param><key>modulation</key><value>modulation</value></param>
<param><key>cp_ratio</key><value>cp_ratio</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0</value></param>
<param><key>type</key><value>'BER'</value></param>
<param><key>win_size</key><value>1000</value></param>
<param><key>bits_per_symbol</key><value>int(math.log(modulation)/math.log(2))</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_scfdma_transmitter_bc_0</source_block_id><sink_block_id>ofdm_scfdma_receiver_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_scfdma_receiver_cb_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>ofdm_scfdma_transmitter_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
