<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from ofdm.preambles_grc import default_block_header</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training_data</value></param>
<param><key>value</key><value>default_block_header(subcarriers,fft_length,fbmc,estimation_preamble,[])</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>subcarriers</value></param>
<param><key>label</key><value>subcarriers</value></param>
<param><key>value</key><value>208</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fbmc</value></param>
<param><key>label</key><value>fbmc</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_length</value></param>
<param><key>label</key><value>fft_length</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>estimation_preamble</value></param>
<param><key>label</key><value>estimation_preamble</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ber_window</value></param>
<param><key>label</key><value>ber_window</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>ofdm_ber_reference_source</key>
<param><key>id</key><value>ofdm_ber_reference_source_0</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
<param><key>data_blocks</key><value>data_blocks</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_2</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>ofdm_ber_measurement</key>
<param><key>id</key><value>ofdm_ber_measurement_0</value></param>
<param><key>sliding_window_length</key><value>ber_window</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>ofdm_vector_sampler</key>
<param><key>id</key><value>ofdm_vector_sampler_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>itemsize</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>data_blocks</value></param>
<param><key>label</key><value>data_blocks</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_3</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>20</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>address</key><value>"tcp://*:5556"</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>tigr_ber_measurement</value></param>
<param><key>title</key><value>TIGR_BER_Measurement</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>zeromq_pub_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_vector_sampler_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_ber_measurement_0</source_block_id><sink_block_id>ofdm_vector_sampler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_ber_reference_source_0</source_block_id><sink_block_id>ofdm_ber_measurement_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ofdm_ber_reference_source_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>ofdm_ber_reference_source_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>ofdm_ber_measurement_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_3</source_block_id><sink_block_id>ofdm_vector_sampler_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
