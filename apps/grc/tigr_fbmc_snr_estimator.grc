<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tigr_fbmc_snr_estimator</value></param>
<param><key>title</key><value>TIGR_FBMC_SNR_Estimator</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training_data</value></param>
<param><key>value</key><value>default_block_header(subcarriers,fft_length,fbmc,estimation_preamble,[])</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from ofdm.preambles_grc import default_block_header</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>subcarriers</value></param>
<param><key>label</key><value>subcarriers</value></param>
<param><key>value</key><value>208</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fbmc</value></param>
<param><key>label</key><value>fbmc</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_length</value></param>
<param><key>label</key><value>fft_length</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>estimation_preamble</value></param>
<param><key>label</key><value>estimation_preamble</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_length</value></param>
<param><key>label</key><value>frame_length</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>subcarriers</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>ofdm_fbmc_snr_filter</key>
<param><key>id</key><value>ofdm_fbmc_snr_filter_0</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
<param><key>frame_length</key><value>frame_length</value></param>
<param><key>training_data</key><value>training_data</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>n</key><value>10</value></param>
<param><key>k</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>20</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>address</key><value>"tcp://*:5555"</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>0.1</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>training_data.fbmc_no_preambles/2 -1</value></param>
<param><key>vlen</key><value>subcarriers</value></param>
</block>
<block>
<key>ofdm_fbmc_snr_estimator</key>
<param><key>id</key><value>ofdm_fbmc_snr_estimator_0</value></param>
<param><key>vlen</key><value>subcarriers</value></param>
<param><key>skip</key><value>training_data.fbmc_no_preambles/2-1</value></param>
</block>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>zeromq_pub_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ofdm_fbmc_snr_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>ofdm_fbmc_snr_filter_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_snr_filter_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_snr_estimator_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_snr_estimator_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>ofdm_fbmc_snr_estimator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
