<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tigr_fbmc_usrp_tx</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>coding</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>whitener_seed</value></param>
<param><key>value</key><value>seed(1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_length</value></param>
<param><key>value</key><value>2*data_part + training_data.fbmc_no_preambles</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>disable_freq_sync</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>estimation_preamble</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>repeated_id_bits</value></param>
<param><key>value</key><value>subcarriers/used_id_bits</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ber_window</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interleaver</value></param>
<param><key>value</key><value>trellis.interleaver(2000,666)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training_data</value></param>
<param><key>value</key><value>default_block_header(subcarriers,fft_length,fbmc,estimation_preamble,[])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fbmc</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_length</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subcarriers</value></param>
<param><key>value</key><value>208</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_length</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>used_id_bits</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>id_blocks</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chunkdivisor</value></param>
<param><key>value</key><value>int(numpy.ceil(data_blocks/5.0))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_part</value></param>
<param><key>value</key><value>data_blocks + id_blocks</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>whitener_pn</value></param>
<param><key>value</key><value>[randint(0,1) for i in range(used_id_bits*repeated_id_bits)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_blocks</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SNR</value></param>
<param><key>value</key><value>-2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3125000/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>value</key><value>2.48e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>init_amplitude</value></param>
<param><key>value</key><value>0.02</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fft_length</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>window</key><value>[]</value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from ofdm.preambles_grc import default_block_header</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>Import</value></param>
<param><key>import</key><value>import math, numpy, copy</value></param>
</block>
<block>
<key>ofdm_fbmc_separate_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_separate_vcvc_1</value></param>
<param><key>M</key><value>fft_length</value></param>
<param><key>num_output</key><value>2</value></param>
</block>
<block>
<key>ofdm_fbmc_polyphase_network_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_polyphase_network_vcvc_0</value></param>
<param><key>M</key><value>fft_length</value></param>
<param><key>K</key><value>filter_length</value></param>
<param><key>reverse</key><value>False</value></param>
<param><key>lp</key><value>filter_length*fft_length-1</value></param>
</block>
<block>
<key>ofdm_fbmc_oqam_preprocessing_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_oqam_preprocessing_vcvc_0</value></param>
<param><key>M</key><value>subcarriers</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>theta_sel</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>from gnuradio import trellis</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from random import seed,randint, getrandbits</value></param>
</block>
<block>
<key>ofdm_fbmc_overlapping_parallel_to_serial_vcc</key>
<param><key>id</key><value>ofdm_fbmc_overlapping_parallel_to_serial_vcc_0</value></param>
<param><key>M</key><value>fft_length</value></param>
</block>
<block>
<key>ofdm_fbmc_pilot_block_inserter</key>
<param><key>id</key><value>ofdm_fbmc_pilot_block_inserter_0</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
<param><key>frame_data_part</key><value>data_part</value></param>
<param><key>training_data</key><value>training_data</value></param>
<param><key>ant</key><value>5</value></param>
</block>
<block>
<key>ofdm_vector_padding</key>
<param><key>id</key><value>ofdm_vector_padding_0</value></param>
<param><key>carriers</key><value>subcarriers</value></param>
<param><key>vlen</key><value>fft_length</value></param>
<param><key>padding_left</key><value> -1</value></param>
</block>
<block>
<key>ofdm_fbmc_beta_multiplier_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_beta_multiplier_vcvc_0</value></param>
<param><key>M</key><value>fft_length</value></param>
<param><key>K</key><value>filter_length</value></param>
<param><key>lp</key><value>fft_length*fft_length-1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>ofdm_fbmc_polyphase_network_vcvc</key>
<param><key>id</key><value>ofdm_fbmc_polyphase_network_vcvc_1</value></param>
<param><key>M</key><value>fft_length</value></param>
<param><key>K</key><value>filter_length</value></param>
<param><key>reverse</key><value>False</value></param>
<param><key>lp</key><value>filter_length*fft_length-1</value></param>
</block>
<block>
<key>tigr_transmit_control</key>
<param><key>id</key><value>tigr_transmit_control_0</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>used_id_bits</key><value>used_id_bits</value></param>
<param><key>estimation_preamble</key><value>estimation_preamble</value></param>
<param><key>filter_length</key><value>filter_length</value></param>
<param><key>fbmc</key><value>fbmc</value></param>
<param><key>data_blocks</key><value>data_blocks</value></param>
<param><key>data_part</key><value>data_part</value></param>
<param><key>repeated_id_bits</key><value>repeated_id_bits</value></param>
<param><key>coding</key><value>coding</value></param>
</block>
<block>
<key>ofdm_fbmc_channel_hier_cc</key>
<param><key>id</key><value>ofdm_fbmc_channel_hier_cc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>M</key><value>fft_length</value></param>
<param><key>K</key><value>filter_length</value></param>
<param><key>syms_per_frame</key><value>15</value></param>
<param><key>exclude_multipath</key><value>1</value></param>
<param><key>sel_taps</key><value>0</value></param>
<param><key>freq_offset</key><value>0.0</value></param>
<param><key>exclude_noise</key><value>0</value></param>
<param><key>sel_noise_type</key><value>201</value></param>
<param><key>SNR</key><value>SNR</value></param>
<param><key>exclude_preamble</key><value>0</value></param>
<param><key>sel_preamble</key><value>1</value></param>
<param><key>zero_pads</key><value>2</value></param>
<param><key>extra_pad</key><value>1</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>noise_voltage</key><value>math.sqrt(1.0*fft_length/subcarriers)*math.sqrt(0.5)*10**(-SNR/20.0)</value></param>
<param><key>freq_offset</key><value>0.0</value></param>
<param><key>epsilon</key><value>1</value></param>
<param><key>taps</key><value>(1.0 )</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>fbmc_rms_amplifier</key>
<param><key>id</key><value>rms</value></param>
<param><key>amplitude</key><value>init_amplitude</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
</block>
<block>
<key>ofdm_uhd_transmitter</key>
<param><key>id</key><value>ofdm_uhd_transmitter_0</value></param>
<param><key>args</key><value>""</value></param>
<param><key>bandwidth</key><value>samp_rate</value></param>
<param><key>frequency</key><value>tx_freq</value></param>
<param><key>lo_offset</key><value>0</value></param>
<param><key>gain</key><value>15</value></param>
<param><key>spec</key><value>"A:0"</value></param>
<param><key>antenna</key><value>""</value></param>
<param><key>clock_source</key><value>"external"</value></param>
<param><key>time_source</key><value>"external"</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>amplitude</value></param>
<param><key>label</key><value>amplitude</value></param>
<param><key>value</key><value>init_amplitude</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>step</key><value>0.02</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>tx_rpc_manager</key>
<param><key>id</key><value>tx_rpc_manager_0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
<param><key>data_blocks</key><value>data_blocks</value></param>
<param><key>frame_length</key><value>frame_length</value></param>
<param><key>cp_length</key><value>0</value></param>
<param><key>tx_freq</key><value>0.0</value></param>
<param><key>bandwidth</key><value>samp_rate</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_1</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>tx_rpc_manager_0</value></param>
<param><key>function_name</key><value>add_tx_modulation_interface</value></param>
<param><key>function_args</key><value>self.tigr_transmit_control_0.ofdm_allocation_src_0.set_allocation</value></param>
<param><key>poll_rate</key><value>0.000000001</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>tx_rpc_manager_0</value></param>
<param><key>function_name</key><value>add_tx_ampl_interface</value></param>
<param><key>function_args</key><value>self.rms.set_rms_amplitude</value></param>
<param><key>poll_rate</key><value>0.000000001</value></param>
</block>
<connection><source_block_id>ofdm_fbmc_polyphase_network_vcvc_0</source_block_id><sink_block_id>ofdm_fbmc_overlapping_parallel_to_serial_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_polyphase_network_vcvc_1</source_block_id><sink_block_id>ofdm_fbmc_overlapping_parallel_to_serial_vcc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_separate_vcvc_1</source_block_id><sink_block_id>ofdm_fbmc_polyphase_network_vcvc_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_oqam_preprocessing_vcvc_0</source_block_id><sink_block_id>ofdm_fbmc_pilot_block_inserter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_pilot_block_inserter_0</source_block_id><sink_block_id>ofdm_vector_padding_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_beta_multiplier_vcvc_0</source_block_id><sink_block_id>fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1</source_block_id><sink_block_id>ofdm_fbmc_separate_vcvc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tigr_transmit_control_0</source_block_id><sink_block_id>ofdm_fbmc_oqam_preprocessing_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_separate_vcvc_1</source_block_id><sink_block_id>ofdm_fbmc_polyphase_network_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_vector_padding_0</source_block_id><sink_block_id>ofdm_fbmc_beta_multiplier_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fbmc_overlapping_parallel_to_serial_vcc_0</source_block_id><sink_block_id>rms</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rms</source_block_id><sink_block_id>ofdm_uhd_transmitter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
