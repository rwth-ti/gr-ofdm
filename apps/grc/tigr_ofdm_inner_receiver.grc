<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tigr_ofdm_inner_receiver</value></param>
<param><key>title</key><value>TIGR_OFDM_Inner_Receiver</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pd_threshold</value></param>
<param><key>value</key><value>0.4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pd_lookahead</value></param>
<param><key>value</key><value>2*fft_length</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>inv_preamble_fd</value></param>
<param><key>value</key><value>1./numpy.array( training_data.pilotsym_fd[training_data.channel_estimation_pilot[0] ] )</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training_data</value></param>
<param><key>value</key><value>default_block_header(data_subcarriers,fft_length,fbmc,estimation_preamble,[])</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_length</value></param>
<param><key>label</key><value>fft_length</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>data_blocks</value></param>
<param><key>label</key><value>data_blocks</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from ofdm.preambles_grc import default_block_header</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>disable_freq_sync</value></param>
<param><key>label</key><value>disable_freq_sync</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vector</key><value>[0.0]</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>ofdm_lms_fir_ff</key>
<param><key>id</key><value>ofdm_lms_fir_ff_0</value></param>
<param><key>len</key><value>20</value></param>
<param><key>mu</key><value>0.001</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_3</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>Import</value></param>
<param><key>import</key><value>import math, numpy, copy</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_length</value></param>
<param><key>label</key><value>frame_length</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>input_index</key><value>disable_freq_sync</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>[1]+[0]*(frame_length-1)</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>ofdm_vector_sampler</key>
<param><key>id</key><value>ofdm_vector_sampler_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>itemsize</key><value>1</value></param>
<param><key>vlen</key><value>fft_length/2*frame_length</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>frame_length</value></param>
<param><key>vlen</key><value>fft_length/2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cp_length</value></param>
<param><key>label</key><value>cp_length</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>delay</key><value>(frame_length-10)*fft_length/2 - fft_length/4 -1</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[1./fft_length]*fft_length</value></param>
</block>
<block>
<key>ofdm_recursive_timing_metric</key>
<param><key>id</key><value>ofdm_recursive_timing_metric_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fft_length</key><value>2*fft_length</value></param>
</block>
<block>
<key>ofdm_peak_detector_02_fb</key>
<param><key>id</key><value>ofdm_peak_detector_02_fb_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>look_ahead</key><value>pd_lookahead</value></param>
<param><key>threshold</key><value>pd_threshold</value></param>
</block>
<block>
<key>ofdm_mm_frequency_estimator</key>
<param><key>id</key><value>ofdm_mm_frequency_estimator_0</value></param>
<param><key>vlen</key><value>fft_length</value></param>
<param><key>identical_parts</key><value>8</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>ofdm_frequency_shift_vcc</key>
<param><key>id</key><value>ofdm_frequency_shift_vcc_0</value></param>
<param><key>vlen</key><value>fft_length</value></param>
<param><key>sensitivity</key><value>-1.0/fft_length</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fft_length</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>[]</value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>ofdm_vector_sampler</key>
<param><key>id</key><value>ofdm_vector_sampler_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>itemsize</key><value>fft_length</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>delay</key><value>1</value></param>
</block>
<block>
<key>ofdm_vector_sampler</key>
<param><key>id</key><value>ofdm_vector_sampler_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>itemsize</key><value>subcarriers</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>ofdm_multiply_const_vcc</key>
<param><key>id</key><value>ofdm_multiply_const_vcc_0</value></param>
<param><key>k</key><value>list(inv_preamble_fd)</value></param>
</block>
<block>
<key>ofdm_vector_mask</key>
<param><key>id</key><value>ofdm_vector_mask_0</value></param>
<param><key>vlen</key><value>fft_length</value></param>
<param><key>cut_left</key><value>(fft_length-subcarriers)/2</value></param>
<param><key>mask_len</key><value>subcarriers</value></param>
<param><key>mask</key><value>[]</value></param>
</block>
<block>
<key>ofdm_time_sync</key>
<param><key>id</key><value>ofdm_time_sync_0</value></param>
<param><key>vlen</key><value>fft_length</value></param>
<param><key>cplen</key><value>cp_length</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>subcarriers</value></param>
</block>
<block>
<key>ofdm_channel_equalizer</key>
<param><key>id</key><value>ofdm_channel_equalizer_0</value></param>
<param><key>vlen</key><value>subcarriers</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>estimation_preamble</value></param>
<param><key>label</key><value>estimation_preamble</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>subcarriers</value></param>
<param><key>label</key><value>subcarriers</value></param>
<param><key>value</key><value>208</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>data_subcarriers</value></param>
<param><key>label</key><value>data_subcarriers</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fbmc</value></param>
<param><key>label</key><value>fbmc</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>ofdm_autocorrelator</key>
<param><key>id</key><value>ofdm_autocorrelator_1</value></param>
<param><key>lag</key><value>fft_length</value></param>
<param><key>n_samples</key><value>cp_length</value></param>
</block>
<block>
<key>ofdm_autocorrelator</key>
<param><key>id</key><value>ofdm_autocorrelator_0</value></param>
<param><key>lag</key><value>fft_length/2</value></param>
<param><key>n_samples</key><value>fft_length/2</value></param>
</block>
<block>
<key>ofdm_lms_phase_tracking_02</key>
<param><key>id</key><value>ofdm_lms_phase_tracking_02_0</value></param>
<param><key>vlen</key><value>subcarriers</value></param>
<param><key>pilot_subc</key><value>training_data.pilot_tones</value></param>
<param><key>nondata_blocks</key><value>[0,1]</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>subcarriers</value></param>
</block>
<block>
<key>ofdm_postprocess_CTF_estimate</key>
<param><key>id</key><value>ofdm_postprocess_CTF_estimate_0</value></param>
<param><key>vlen</key><value>subcarriers</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ofdm_recursive_timing_metric_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_recursive_timing_metric_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>ofdm_peak_detector_02_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_peak_detector_02_fb_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>ofdm_vector_sampler_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_vector_sampler_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>ofdm_vector_sampler_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_vector_sampler_0_0</source_block_id><sink_block_id>ofdm_mm_frequency_estimator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_mm_frequency_estimator_0</source_block_id><sink_block_id>ofdm_lms_fir_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_lms_fir_ff_0</source_block_id><sink_block_id>blocks_keep_one_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>ofdm_frequency_shift_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>ofdm_frequency_shift_vcc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>ofdm_frequency_shift_vcc_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ofdm_lms_fir_ff_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1</source_block_id><sink_block_id>pad_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ofdm_autocorrelator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ofdm_autocorrelator_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_autocorrelator_0</source_block_id><sink_block_id>ofdm_time_sync_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_autocorrelator_1</source_block_id><sink_block_id>ofdm_time_sync_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ofdm_time_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_time_sync_0</source_block_id><sink_block_id>ofdm_vector_sampler_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_time_sync_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_time_sync_0</source_block_id><sink_block_id>ofdm_frequency_shift_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_time_sync_0</source_block_id><sink_block_id>ofdm_frequency_shift_vcc_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ofdm_frequency_shift_vcc_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>ofdm_vector_mask_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_time_sync_0</source_block_id><sink_block_id>ofdm_vector_sampler_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>ofdm_vector_sampler_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_vector_mask_0</source_block_id><sink_block_id>ofdm_vector_sampler_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_vector_sampler_1</source_block_id><sink_block_id>ofdm_multiply_const_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_multiply_const_vcc_0</source_block_id><sink_block_id>ofdm_postprocess_CTF_estimate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_postprocess_CTF_estimate_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_time_sync_0</source_block_id><sink_block_id>ofdm_channel_equalizer_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ofdm_time_sync_0</source_block_id><sink_block_id>ofdm_lms_phase_tracking_02_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_channel_equalizer_0</source_block_id><sink_block_id>ofdm_lms_phase_tracking_02_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_lms_phase_tracking_02_0</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_postprocess_CTF_estimate_0</source_block_id><sink_block_id>ofdm_channel_equalizer_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_vector_mask_0</source_block_id><sink_block_id>ofdm_channel_equalizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_time_sync_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
