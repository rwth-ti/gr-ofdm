<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tigr_ofdm_uncoded_usrp_rx</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>repeated_id_bits</value></param>
<param><key>value</key><value>data_subcarriers/used_id_bits</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>disable_freq_sync</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_length</value></param>
<param><key>value</key><value>fft_length/8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fbmc</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_length</value></param>
<param><key>value</key><value>data_part + training_data.no_preambles</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_length</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>whitener_seed</value></param>
<param><key>value</key><value>seed(1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interleaver</value></param>
<param><key>value</key><value>trellis.interleaver(2000,666)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_length</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>used_id_bits</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>id_blocks</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_blocks</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>coding</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ber_window</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_subcarriers</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training_data</value></param>
<param><key>value</key><value>default_block_header(data_subcarriers,fft_length,fbmc,estimation_preamble,[])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chunkdivisor</value></param>
<param><key>value</key><value>int(numpy.ceil(data_blocks/5.0))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>estimation_preamble</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_part</value></param>
<param><key>value</key><value>data_blocks + id_blocks</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>whitener_pn</value></param>
<param><key>value</key><value>[randint(0,1) for i in range(used_id_bits*repeated_id_bits)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subcarriers</value></param>
<param><key>value</key><value>data_subcarriers+8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_hostname</value></param>
<param><key>value</key><value>"tabur"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>2480000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3125000.0/2</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>Import</value></param>
<param><key>import</key><value>import math, numpy, copy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>from gnuradio import trellis</value></param>
</block>
<block>
<key>ofdm_dynamic_trigger_ib</key>
<param><key>id</key><value>ofdm_dynamic_trigger_ib_0</value></param>
<param><key>first_or_last</key><value>0</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>address</key><value>"tcp://*:5557"</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>20</value></param>
<param><key>vlen</key><value>data_subcarriers</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>data_subcarriers</value></param>
<param><key>address</key><value>"tcp://*:5559"</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>tigr_ber_measurement</key>
<param><key>id</key><value>tigr_ber_measurement_0</value></param>
<param><key>subcarriers</key><value>data_subcarriers</value></param>
<param><key>fbmc</key><value>fbmc</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>estimation_preamble</key><value>estimation_preamble</value></param>
<param><key>ber_window</key><value>ber_window</value></param>
<param><key>data_blocks</key><value>data_blocks</value></param>
</block>
<block>
<key>ofdm_pilot_subcarrier_filter</key>
<param><key>id</key><value>ofdm_pilot_subcarrier_filter_0_0</value></param>
<param><key>itemsize</key><value>float</value></param>
<param><key>data_subcarriers</key><value>data_subcarriers</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
<param><key>training_data</key><value>training_data</value></param>
<param><key>complex_value</key><value>False</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>0.1</value></param>
<param><key>vlen</key><value>data_subcarriers</value></param>
</block>
<block>
<key>ofdm_pilot_block_filter</key>
<param><key>id</key><value>ofdm_pilot_block_filter_0</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
<param><key>frame_length</key><value>frame_length</value></param>
<param><key>training_data</key><value>training_data</value></param>
</block>
<block>
<key>tigr_ofdm_snr_estimator</key>
<param><key>id</key><value>tigr_ofdm_snr_estimator_0</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
<param><key>frame_length</key><value>frame_length</value></param>
</block>
<block>
<key>ofdm_vector_sampler</key>
<param><key>id</key><value>ofdm_vector_sampler_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>itemsize</key><value>data_subcarriers</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from ofdm.preambles_grc import default_block_header</value></param>
</block>
<block>
<key>ofdm_coded_bpsk_soft_decoder</key>
<param><key>id</key><value>ofdm_coded_bpsk_soft_decoder_0</value></param>
<param><key>vlen</key><value>data_subcarriers</value></param>
<param><key>output_bits</key><value>used_id_bits</value></param>
<param><key>whitener</key><value>whitener_pn</value></param>
</block>
<block>
<key>ofdm_frame_sampler</key>
<param><key>id</key><value>ofdm_frame_sampler_0</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
<param><key>frame_length</key><value>frame_length</value></param>
</block>
<block>
<key>tigr_ofdm_inner_receiver</key>
<param><key>id</key><value>tigr_ofdm_inner_receiver_0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>data_blocks</key><value>data_blocks</value></param>
<param><key>frame_length</key><value>frame_length</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>estimation_preamble</key><value>estimation_preamble</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
<param><key>data_subcarriers</key><value>data_subcarriers</value></param>
<param><key>fbmc</key><value>0</value></param>
<param><key>disable_freq_sync</key><value>disable_freq_sync</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from random import seed,randint, getrandbits</value></param>
</block>
<block>
<key>rx_rpc_manager</key>
<param><key>id</key><value>rx_rpc_manager_0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>rx_rpc_manager_0</value></param>
<param><key>function_name</key><value>add_set_scatter_subcarrier_interface</value></param>
<param><key>function_args</key><value>self.tigr_scatterplot_0.ofdm_vector_element_0.set_element</value></param>
<param><key>poll_rate</key><value>0.000000001</value></param>
</block>
<block>
<key>ofdm_uhd_receiver</key>
<param><key>id</key><value>ofdm_uhd_receiver_0</value></param>
<param><key>args</key><value>""</value></param>
<param><key>bandwidth</key><value>samp_rate</value></param>
<param><key>frequency</key><value>rx_freq</value></param>
<param><key>lo_offset</key><value>0</value></param>
<param><key>gain</key><value>20</value></param>
<param><key>spec</key><value>""</value></param>
<param><key>antenna</key><value>""</value></param>
<param><key>clock_source</key><value>"external"</value></param>
<param><key>time_source</key><value>"none"</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>tigr_scatterplot</key>
<param><key>id</key><value>tigr_scatterplot_0</value></param>
<param><key>subcarriers</key><value>data_subcarriers</value></param>
<param><key>fbmc</key><value>fbmc</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>estimation_preamble</key><value>estimation_preamble</value></param>
<param><key>data_blocks</key><value>data_blocks</value></param>
<param><key>data_part</key><value>11</value></param>
<param><key>frame_length</key><value>frame_length</value></param>
</block>
<block>
<key>ofdm_generic_demapper_vcb</key>
<param><key>id</key><value>ofdm_generic_demapper_vcb_0</value></param>
<param><key>vlen</key><value>data_subcarriers</value></param>
<param><key>frame_size</key><value>data_part</value></param>
</block>
<block>
<key>ofdm_pilot_subcarrier_filter</key>
<param><key>id</key><value>ofdm_pilot_subcarrier_filter_0</value></param>
<param><key>itemsize</key><value>complex</value></param>
<param><key>data_subcarriers</key><value>data_subcarriers</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
<param><key>training_data</key><value>training_data</value></param>
<param><key>complex_value</key><value>True</value></param>
</block>
<block>
<key>ofdm_allocation_buffer</key>
<param><key>id</key><value>ofdm_allocation_buffer_0</value></param>
<param><key>subcarriers</key><value>data_subcarriers</value></param>
<param><key>data_symbols</key><value>data_blocks</value></param>
<param><key>address</key><value>"tcp://"+tx_hostname+":3333"</value></param>
<param><key>coding</key><value>0</value></param>
</block>
<block>
<key>ofdm_multiply_frame_fc</key>
<param><key>id</key><value>ofdm_multiply_frame_fc_0</value></param>
<param><key>frame_size</key><value>data_part</value></param>
<param><key>subc</key><value>data_subcarriers</value></param>
</block>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_keep_one_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_vector_sampler_0</source_block_id><sink_block_id>ofdm_coded_bpsk_soft_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_coded_bpsk_soft_decoder_0</source_block_id><sink_block_id>ofdm_allocation_buffer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_dynamic_trigger_ib_0</source_block_id><sink_block_id>tigr_ber_measurement_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1</source_block_id><sink_block_id>zeromq_pub_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_allocation_buffer_0</source_block_id><sink_block_id>ofdm_dynamic_trigger_ib_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_coded_bpsk_soft_decoder_0</source_block_id><sink_block_id>tigr_ber_measurement_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_allocation_buffer_0</source_block_id><sink_block_id>tigr_ber_measurement_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_allocation_buffer_0</source_block_id><sink_block_id>ofdm_generic_demapper_vcb_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_generic_demapper_vcb_0</source_block_id><sink_block_id>tigr_ber_measurement_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>tigr_ofdm_inner_receiver_0</source_block_id><sink_block_id>ofdm_frame_sampler_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>tigr_ofdm_inner_receiver_0</source_block_id><sink_block_id>ofdm_frame_sampler_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_frame_sampler_0</source_block_id><sink_block_id>tigr_ofdm_snr_estimator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_frame_sampler_0</source_block_id><sink_block_id>tigr_ofdm_snr_estimator_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_frame_sampler_0</source_block_id><sink_block_id>ofdm_pilot_block_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_frame_sampler_0</source_block_id><sink_block_id>ofdm_pilot_block_filter_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_pilot_block_filter_0</source_block_id><sink_block_id>ofdm_pilot_subcarrier_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tigr_ofdm_inner_receiver_0</source_block_id><sink_block_id>zeromq_pub_sink_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tigr_ofdm_inner_receiver_0</source_block_id><sink_block_id>ofdm_pilot_subcarrier_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_pilot_subcarrier_filter_0_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_pilot_block_filter_0</source_block_id><sink_block_id>ofdm_vector_sampler_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_pilot_subcarrier_filter_0</source_block_id><sink_block_id>ofdm_vector_sampler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_uhd_receiver_0</source_block_id><sink_block_id>tigr_ofdm_inner_receiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_multiply_frame_fc_0</source_block_id><sink_block_id>tigr_scatterplot_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_multiply_frame_fc_0</source_block_id><sink_block_id>ofdm_generic_demapper_vcb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_pilot_subcarrier_filter_0</source_block_id><sink_block_id>ofdm_multiply_frame_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_allocation_buffer_0</source_block_id><sink_block_id>ofdm_multiply_frame_fc_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
</flow_graph>
