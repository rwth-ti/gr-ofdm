<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from ofdm.preambles_grc import default_block_header</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training_data</value></param>
<param><key>value</key><value>default_block_header(subcarriers,fft_length,fbmc,estimation_preamble,[])</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>subcarriers</value></param>
<param><key>label</key><value>subcarriers</value></param>
<param><key>value</key><value>208</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fbmc</value></param>
<param><key>label</key><value>fbmc</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_length</value></param>
<param><key>label</key><value>fft_length</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>estimation_preamble</value></param>
<param><key>label</key><value>estimation_preamble</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>data_blocks</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>n</key><value>20</value></param>
<param><key>vlen</key><value>data_blocks</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>data_blocks</value></param>
<param><key>address</key><value>"tcp://*:5560"</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>data_blocks</value></param>
<param><key>label</key><value>data_blocks</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>data_part</value></param>
<param><key>label</key><value>data_part</value></param>
<param><key>value</key><value>11</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_length</value></param>
<param><key>label</key><value>frame_length</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>subcarriers</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>[1] + [0]*(data_part-1)</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>scatterplot_subcarrier_filter</key>
<param><key>id</key><value>scatterplot_subcarrier_filter_0</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
<param><key>data_blocks</key><value>data_blocks</value></param>
</block>
<block>
<key>ofdm_vector_element</key>
<param><key>id</key><value>ofdm_vector_element_0</value></param>
<param><key>vlen</key><value>subcarriers</value></param>
<param><key>element</key><value>40</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>tigr_scatterplot</value></param>
<param><key>title</key><value>TIGR_Scatterplot</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>zeromq_pub_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_vector_element_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>scatterplot_subcarrier_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>scatterplot_subcarrier_filter_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>scatterplot_subcarrier_filter_0</source_block_id><sink_block_id>ofdm_vector_element_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
