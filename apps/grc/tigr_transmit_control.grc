<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tigr_transmit_control</value></param>
<param><key>title</key><value>TIGR_Transmit_Control</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>whitener_pn</value></param>
<param><key>value</key><value>[randint(0,1) for i in range(used_id_bits*repeated_id_bits)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interleaver</value></param>
<param><key>value</key><value>trellis.interleaver(2000,666)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training_data</value></param>
<param><key>value</key><value>default_block_header(subcarriers,fft_length,fbmc,estimation_preamble,[])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>whitener_seed</value></param>
<param><key>value</key><value>seed(1)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>subcarriers</value></param>
<param><key>label</key><value>subcarriers</value></param>
<param><key>value</key><value>208</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_length</value></param>
<param><key>label</key><value>fft_length</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>used_id_bits</value></param>
<param><key>label</key><value>used_id_bits</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>estimation_preamble</value></param>
<param><key>label</key><value>estimation_preamble</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>filter_length</value></param>
<param><key>label</key><value>filter_length</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>Import</value></param>
<param><key>import</key><value>import math, numpy, copy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from random import seed,randint, getrandbits</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>from gnuradio import trellis</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from ofdm.preambles_grc import default_block_header</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fbmc</value></param>
<param><key>label</key><value>fbmc</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>data_blocks</value></param>
<param><key>label</key><value>data_blocks</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>data_part</value></param>
<param><key>label</key><value>data_part</value></param>
<param><key>value</key><value>11</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>n</key><value>2*40</value></param>
<param><key>vlen</key><value>subcarriers</value></param>
</block>
<block>
<key>ofdm_generic_mapper_bcv</key>
<param><key>id</key><value>ofdm_generic_mapper_bcv_0</value></param>
<param><key>vlen</key><value>subcarriers</value></param>
<param><key>coding</key><value>1</value></param>
<param><key>frame_size</key><value>data_part</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>subcarriers</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>subcarriers</value></param>
<param><key>address</key><value>"tcp://*:4445"</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>subcarriers</value></param>
<param><key>address</key><value>"tcp://*:4444"</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>ofdm_repetition_encoder_sb</key>
<param><key>id</key><value>ofdm_repetition_encoder_sb_0</value></param>
<param><key>input_bits</key><value>used_id_bits</value></param>
<param><key>repetitions</key><value>repeated_id_bits</value></param>
<param><key>whitener</key><value>whitener_pn</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>40</value></param>
<param><key>vlen</key><value>subcarriers</value></param>
</block>
<block>
<key>ofdm_multiply_frame_fc</key>
<param><key>id</key><value>ofdm_multiply_frame_fc_0</value></param>
<param><key>frame_size</key><value>data_part</value></param>
<param><key>subc</key><value>subcarriers</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>coding</value></param>
<param><key>label</key><value>coding</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>repeated_id_bits</value></param>
<param><key>label</key><value>repeated_id_bits</value></param>
<param><key>value</key><value>26</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>2</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>output_index</key><value>coding</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>trellis_encoder_xx</key>
<param><key>id</key><value>trellis_encoder_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>bb</value></param>
<param><key>fsm_args</key><value>trellis.fsm(1,2,[91,121])</value></param>
<param><key>init_state</key><value>0</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>k</key><value>2</value></param>
</block>
<block>
<key>ofdm_puncture_bb</key>
<param><key>id</key><value>ofdm_puncture_bb_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>vlen</key><value>subcarriers</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>[1]+[0]*(data_blocks/2-1)</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>input_index</key><value>coding</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>trellis_permutation</key>
<param><key>id</key><value>trellis_permutation_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>interleaver_size</key><value>interleaver.K()</value></param>
<param><key>table</key><value>interleaver.INTER()</value></param>
<param><key>syms_per_block</key><value>1</value></param>
</block>
<block>
<key>ofdm_allocation_src</key>
<param><key>id</key><value>ofdm_allocation_src_0</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
<param><key>data_symbols</key><value>data_blocks</value></param>
<param><key>address</key><value>"tcp://*:3333"</value></param>
<param><key>coding</key><value>0</value></param>
</block>
<block>
<key>ofdm_tx_mux_ctrl</key>
<param><key>id</key><value>ofdm_tx_mux_ctrl_0</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
</block>
<block>
<key>ofdm_ber_reference_source</key>
<param><key>id</key><value>ofdm_ber_reference_source_0</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
<param><key>data_blocks</key><value>data_blocks</value></param>
</block>
<block>
<key>ofdm_stream_controlled_mux_b</key>
<param><key>id</key><value>ofdm_stream_controlled_mux_b_0</value></param>
</block>
<connection><source_block_id>ofdm_allocation_src_0</source_block_id><sink_block_id>ofdm_ber_reference_source_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_allocation_src_0</source_block_id><sink_block_id>ofdm_repetition_encoder_sb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>zeromq_pub_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1</source_block_id><sink_block_id>zeromq_pub_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_encoder_xx_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_puncture_bb_1</source_block_id><sink_block_id>trellis_permutation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>ofdm_puncture_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_allocation_src_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>ofdm_puncture_bb_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ofdm_stream_controlled_mux_b_0</source_block_id><sink_block_id>ofdm_generic_mapper_bcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_generic_mapper_bcv_0</source_block_id><sink_block_id>ofdm_multiply_frame_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_allocation_src_0</source_block_id><sink_block_id>ofdm_generic_mapper_bcv_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_multiply_frame_fc_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>ofdm_stream_controlled_mux_b_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>trellis_permutation_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_allocation_src_0</source_block_id><sink_block_id>blocks_keep_one_in_n_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_allocation_src_0</source_block_id><sink_block_id>ofdm_multiply_frame_fc_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_allocation_src_0</source_block_id><sink_block_id>ofdm_ber_reference_source_0</sink_block_id><source_key>3</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_selector_1</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_selector_2</source_block_id><sink_block_id>trellis_encoder_xx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_2</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_tx_mux_ctrl_0</source_block_id><sink_block_id>ofdm_stream_controlled_mux_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_repetition_encoder_sb_0</source_block_id><sink_block_id>ofdm_stream_controlled_mux_b_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_puncture_bb_1</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_allocation_src_0</source_block_id><sink_block_id>ofdm_puncture_bb_1</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_ber_reference_source_0</source_block_id><sink_block_id>blks2_selector_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_allocation_src_0</source_block_id><sink_block_id>ofdm_tx_mux_ctrl_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_ber_reference_source_0</source_block_id><sink_block_id>ofdm_stream_controlled_mux_b_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
</flow_graph>
